LR_IROM1 0x08000000 0x8000 {
  ER_IROM1 0x08000000 0x8000 {
    *.o (RESET, +First)
    *(InRoot$$Sections)
    .ANY (+RO)
    .ANY (+XO)
  }
  RW_IRAM1 0x20000000 0x1000 { .ANY (+RW +ZI) }
}
